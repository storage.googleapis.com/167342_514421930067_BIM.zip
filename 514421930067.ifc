Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-25T15:54:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 25 15:54:23 2019 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{2474464D-958C-4916-BA2D-BAC61FAA39BE}\ifc * Database version: 5507 * Database creation date: Mon Mar 25 15:54:22 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 25 15:54:22 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 25 15:54:22 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 514421930067 Bath and shower faucet, 514421930067:514421930067 Bath and shower faucet:363227
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 178.5 mm; NominalHeight: 122 mm; NominalWidth: 220.3 mm; Projection: 157 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 514421930067; ConvergoRefNr: 0087-1803-0073-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for sinks; NBSReference: 45-35-70/345; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/03/2019
Type - Green Building Properties(Type) - Approval ACS: 16 ACC NY 205; Approval CSTB: 322-M1-17/1; Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 4057304002946; EN Standard: EN 817; URL ACS: http://static.hansa.com/ACS/514421930067; URL CSTB: http://static.hansa.com/CSTB/514421930067
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/514421930067; Catalog Drawing URL: http://static.hansa.com/catdrw/514421930067; Class: Single lever; Dimension Drawing URL: http://static.hansa.com/dimdrw/514421930067; FDV Document URL: http://www.hansa.com/datasheet/514421930067/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/514421930067; Group: Bath and shower faucets; Manufacturer: Hansa; Market: BEL;CZE;ESP;FRA;INT;ITA;NLD;SVK; Model: 514421930067 Bath and shower faucet; Name_en: 514421930067 Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 176 x 162; Package Weight: 2.068 kg; Product Code: 514421930067; Product Datasheet: http://www.hansa.com/datasheet/514421930067/en; Product Family: HANSAPOLO; Product Image URL: http://static.hansa.com/image/514421930067; Product URL: http://static.hansa.com/514421930067; Type Name: 514421930067 Bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass; Aerator: CASCADE®; Connection: Eccentric unions; Connection Size: G1/2; Diverter: Pull diverter; DN Size: DN15; Flow: Limitation option for maximum flow rate; Flow Rate At 300kPa: 0.0116538 m3/s; Installation and Maintenance: http://static.hansa.com/manual/514421930067; Installation Type: Wall-mounted; Installation Width: cc150 ± 15 mm; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Non-return valve(s); Noise Class: I(ISO 3822); Spare Parts: http://static.hansa.com/sp/514421930067; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 514421930067; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 514421930067; Name: 514421930067 Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220x180x122 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 514421930067; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 514421930067 Bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0898921 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00480348 m3
Identity Data - Mark: 27
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 514421930067: 514421930067 Bath and shower faucet; Family and Type: 514421930067: 514421930067 Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 514421930067: 514421930067 Bath and shower faucet; Type Id: 514421930067: 514421930067 Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
